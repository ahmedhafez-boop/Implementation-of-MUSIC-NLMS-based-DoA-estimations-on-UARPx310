options:
  parameters:
    author: ahmed
    generate_options: qt_gui
    id: usrp_music
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable_qtgui_range
  parameters:
    label: AoA
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: phase_shift
  id: variable_qtgui_range
  parameters:
    label: phase_shift
    start: '-180'
    step: '0.1'
    stop: '180'
    value: '174.000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 196e3
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 3e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-90'
    type: short
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '181'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: short
  states: {}
- name: blocks_phase_shift_0_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phase_shift
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      music_doa_block.py
      ------------------
      MUSIC Direction-of-Arrival embedded Python block for GNU Radio.

      Signal model — 2-element ULA, d = λ/2 spacing:
          x1(t) = s(t) + n1(t)
          x2(t) = s(t)·exp(j·π·sin θ) + n2(t)

      Steering vector:  a(θ) = [1,  exp(j·π·sin θ)]ᵀ

      MUSIC pseudospectrum:
          P(θ) = 1 / ( aᴴ(θ) · Eₙ · Eₙᴴ · a(θ) )

      The peak of P(θ) is the estimated angle of arrival.

      Place this file in the same directory as music_sim.py.
      """

      import numpy as np
      from gnuradio import gr


      class music_doa(gr.basic_block):
          """
          MUSIC DOA Estimator — 2-element ULA

          Ports
          -----
          in0  : complex64   — element 1 received signal
          in1  : complex64   — element 2 received signal
          out0 : float32[num_angles] — MUSIC pseudospectrum  (−90° … +90°)

          Parameters
          ----------
          num_snapshots : int   — samples per covariance estimate  (default 100)
          num_signals   : int   — number of signal sources         (default 1)
          num_angles    : int   — angular grid points              (default 181 → 1°/bin)
          """

          def __init__(self, num_snapshots: int = 100,
                             num_signals:   int = 1,
                             num_angles:    int = 181):

              gr.basic_block.__init__(
                  self,
                  name="MUSIC DOA",
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
              )

              self.N = num_snapshots   # snapshot count
              self.K = num_signals     # number of sources  (must be < 2)
              self.L = num_angles

              # ── Pre-compute steering matrix  A : (2, L) ────────────────
              # a(θ) = [1,  exp(j·π·sinθ)]
              angles_rad = np.deg2rad(np.linspace(-90, 90, num_angles))
              self.A = np.vstack([
                  np.ones(num_angles, dtype=np.complex128),
                  np.exp(1j * np.pi * np.sin(angles_rad)),
              ])  # shape (2, L)

          # ----------------------------------------------------------------
          def general_work(self, input_items, output_items):
              n_in  = min(len(input_items[0]), len(input_items[1]))
              n_out = len(output_items[0])

              # How many full spectrum vectors can we produce?
              n_produce = min(n_out, n_in // self.N)
              if n_produce == 0:
                  return 0

              for i in range(n_produce):
                  s = i * self.N

                  # ── 1. Data matrix  X : (2, N) ──────────────────────────
                  X = np.vstack([
                      input_items[0][s : s + self.N],
                      input_items[1][s : s + self.N],
                  ]).astype(np.complex128)

                  # ── 2. Sample covariance matrix  R : (2, 2) ─────────────
                  R = (X @ X.conj().T) / self.N

                  # ── 3. Eigendecomposition  (eigh → ascending order) ──────
                  _, V = np.linalg.eigh(R)

                  # ── 4. Noise subspace  Eₙ : (2, 2−K) ────────────────────
                  En = V[:, : 2 - self.K]

                  # ── 5. MUSIC pseudospectrum  (vectorised over all angles) ─
                  #   G  = Eₙ Eₙᴴ                     (2×2 noise projector)
                  #   denom[l] = aᴴ(θₗ) G a(θₗ)      (real scalar per angle)
                  G     = En @ En.conj().T                     # (2, 2)
                  AG    = self.A.conj().T @ G                  # (L, 2)
                  denom = np.real(np.einsum("la,al->l", AG, self.A))  # (L,)
                  P     = (1.0 / np.maximum(denom, 1e-10)).astype(np.float32)

                  output_items[0][i] = P

              self.consume_each(n_produce * self.N)
              return n_produce
    num_angles: '181'
    num_signals: '1'
    num_snapshots: '100'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    type: short
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '90'
    min: '-90'
    name: '"Max angle"'
    type: short
    update_time: '0.5'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    update_time: '0.5'
    vlen: '181'
    x_start: '-90'
    x_step: '1.0'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 10e3
    center_freq0: 2.5e9
    clock_source0: internal
    dev_addr: addr=192.168.10.2
    gain0: '13'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 10e3
    bw1: 10e3
    center_freq0: 2.5e9
    center_freq1: 2.5e9
    clock_source0: internal
    dev_addr: addr=192.168.10.2
    gain0: '14'
    gain1: '14'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_argmax_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_argmax_xx_0, '1', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_phase_shift_0_0_0, '0', epy_block_1, '1']
- [epy_block_1, '0', blocks_argmax_xx_0, '0']
- [epy_block_1, '0', qtgui_vector_sink_f_0, '0']
- [uhd_usrp_source_0_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0_0, '1', blocks_phase_shift_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
