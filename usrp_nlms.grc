options:
  parameters:
    author: ahmed
    generate_options: qt_gui
    id: usrp_nlms
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: a
  id: variable_qtgui_range
  parameters:
    label: AoA
    start: '-90'
    step: '1'
    stop: '90'
    value: '0'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 2.4e9
  states: {}
- name: phase_shift
  id: variable_qtgui_range
  parameters:
    label: phase_shift
    start: '-180'
    step: '0.1'
    stop: '180'
    value: '38'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '196000'
  states: {}
- name: u
  id: variable_qtgui_range
  parameters:
    label: u
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.2'
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: 3e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-90'
    type: short
  states: {state: disabled}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: '-90'
    type: short
  states: {state: disabled}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-45'
    type: short
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '91'
  states: {state: disabled}
- name: blocks_argmax_xx_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '181'
  states: {state: disabled}
- name: blocks_argmax_xx_0_1
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: '91'
  states: {}
- name: blocks_phase_shift_0_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phase_shift
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class nlms_doa(gr.basic_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, num_signals = 1, num_angles = 181, num_snapshots=100, step_size = 0.2 ):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.basic_block.__init__(
                  self,
                  name='NLMS for DoA',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],# vector of K floats, not a scalar stream
                 
                  )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.M = num_signals
              self.K = num_angles
              self.N = num_snapshots
              self.u = step_size
              
          def steer(self,theta_deg):
              theta = np.deg2rad(theta_deg)
              
              return np.array([ 1.0, np.exp(-1j * np.pi * np.sin(theta))], dtype=np.complex128)
              
          def general_work(self, input_items, output_items):
              available = min(len(input_items[0]), len(input_items[1]))


              if available < self.N:
                  return 0
              X = np.column_stack([
                  input_items[0][:self.N].astype(np.complex128),
                  input_items[1][:self.N].astype(np.complex128)
                  ])
              angles = np.linspace(-90, 90, self.K)   # [-90°, -89°, ..., 90°]
              norms = np.zeros(self.K, dtype=np.float32)
              powers = np.zeros(self.K, dtype=np.float32)
              for k in range(self.K):
                  w = np.zeros(2, dtype=np.complex128)
                  power_acc = 0.0
                  a_k = self.steer(angles[k])
                  for n in range(self.N):
                      d = np.conj(a_k) @ X[n]  # inner product → scalar ✓  (a^H · x_n)
                      y = np.conj(w) @ X[n]
                      e = d - y     # scalar error ✓             (d - ŵ^H · x_n)
                      xns = np.linalg.norm(X[n])**2 + 1e-10
                      w += (self.u/(xns))* (e.conj())* X[n]
                      power_acc += np.abs(y)**2
                  '''powers[k] = power_acc / self.N'''
                  norms[k] = np.linalg.norm(w)    # real-valued scalar ✓
              output_items[0][0][:] = norms
              print(output_items[0][0][:])
                      

              '''print(np.max(powers), np.min(powers))
              print(np.argmax(powers))    
              output_items[0][0][:] = powers
              '''
              return 1
    num_angles: '181'
    num_signals: '1'
    num_snapshots: '10'
    step_size: '0.2'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          def __init__(self, num_signals=1, num_angles=181, num_snapshots=100, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='New NLMS for DoA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.M = num_signals
              self.K = num_angles
              self.N = num_snapshots
              self.u = step_size
              
              # Precompute search angles and steering matrices
              self.angles = np.linspace(-90, 90, self.K)
              self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)
              for k in range(self.K):
                  theta = np.deg2rad(self.angles[k])
                  self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              n_output = len(out)
              
              for i in range(n_output):
                  # Extract N snapshots for this block processing step 
                  x0 = in0[i*self.N : (i+1)*self.N]
                  x1 = in1[i*self.N : (i+1)*self.N]
                  
                  # Stack into an (N, 2) array so X[n] gives a 2-element row snapshot vector
                  X = np.column_stack([x0, x1]).astype(np.complex128)
                  
                  norms = np.zeros(self.K, dtype=np.float32)
                  
                  # Outer loop over the elements of searching set Theta 
                  for k in range(self.K):
                      w = np.zeros(2, dtype=np.complex128)  # Initialization of weights to 0 
                      a_k = self.steering_matrix[:, k]
                      
                      # Inner loop over snapshots
                      for n in range(self.N):
                          x_n = X[n]
                          
                          # Target steering calculation: d = a^H * X_n 
                          d = np.conj(a_k) @ x_n
                          
                          # Filter output: y = w^H * X_n
                          y = np.conj(w) @ x_n
                          
                          # Scalar error calculation
                          e = d - y
                          
                          # Squared norm of the input vector: ||X_n||^2
                          xns = np.sum(np.abs(x_n)**2) + 1e-10
                          
                          # NLMS Weight Update formula 
                          w += (self.u / xns) * np.conj(e) * x_n
                      
                      # Store Euclidean norm of final weights for this angle
                      norms[k] = np.linalg.norm(w)
                  
                  # Optional: Normalize the spectrum so the peak equals 1.0 (0 dB)
                  max_norm = np.max(norms)
                  if max_norm > 0:
                      norms /= max_norm
                      
                  out[i][:] = norms
                  
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  print(f"NLMS Peak detected at: {self.angles[max_idx]:.1f}°")
                  
              return n_output
    num_angles: '181'
    num_signals: '1'
    num_snapshots: '20'
    step_size: '0.5'
  states: {state: disabled}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          def __init__(self, num_signals=1, num_angles=91, num_snapshots=30, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='optimized code NLMS for DoA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.M = num_signals
              self.K = num_angles
              self.N = num_snapshots
              self.u = step_size
              
              # Precompute search angles and steering matrices
              self.angles = np.linspace(-90, 90, self.K)
              self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)
              for k in range(self.K):
                  theta = np.deg2rad(self.angles[k])
                  self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              n_output = len(out)
              
              # Precompute Hermitian (conjugate transpose) of the steering matrix
              # steering_matrix is (2, K), so A_H becomes (K, 2)
              A_H = np.conj(self.steering_matrix).T
              
              for i in range(n_output):
                  # Extract N snapshots for this block processing step 
                  x0 = in0[i*self.N : (i+1)*self.N]
                  x1 = in1[i*self.N : (i+1)*self.N]
                  
                  # Stack into an (N, 2) matrix
                  X = np.column_stack([x0, x1]).astype(np.complex128)
                  
                  # Initialize weight vectors for ALL K angles simultaneously: shape (K, 2)
                  W = np.zeros((self.K, 2), dtype=np.complex128)
                  
                  # Precompute desired signal 'd' for all angles across all snapshots
                  # Matrix multiply: (K, 2) x (2, N) -> Resulting shape is (K, N)
                  D_matrix = A_H @ X.T
                  
                  # Loop ONLY over the snapshots (100 steps instead of 18,100!)
                  for n in range(self.N):
                      x_n = X[n]  # Current 2-element snapshot vector: shape (2,)
                      
                      # Compute filter output y = w^H * x_n for all K angles simultaneously
                      # Row-wise dot product via broadcasting and summing along columns
                      Y = np.sum(np.conj(W) * x_n, axis=1)  # shape (K,)
                      
                      # Extract desired signal vector for this snapshot step
                      D = D_matrix[:, n]  # shape (K,)
                      
                      # Scalar error for all angles
                      E = D - Y  # shape (K,)
                      
                      # Squared norm of the input vector (scalar, identical across all angles)
                      xns = np.sum(np.abs(x_n)**2) + 1e-10
                      
                      # Fully vectorized NLMS weight update rule across all angles
                      # (K, 1) matrix multiplied by (1, 2) matrix updates the (K, 2) weight matrix instantly
                      W += (self.u / xns) * (np.conj(E)[:, None] * x_n[None, :])
                  
                  # Compute Euclidean norm of final weights for each angle out of the loop
                  norms = np.linalg.norm(W, axis=1)
                  
                  # Normalize the spectrum so the peak equals 1.0 (0 dB)
                  '''max_norm = np.max(norms)
                  if max_norm > 0:
                      norms /= max_norm'''
                      
                  out[i][:] = norms
                  
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  '''print(f"NLMS Peak detected at: {self.angles[max_idx]:.1f}°")'''
                  
              return n_output
    num_angles: '91'
    num_signals: '1'
    num_snapshots: '30'
    step_size: u
  states: {state: disabled}
- name: epy_block_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          def __init__(self, num_signals=1, num_angles=181, num_snapshots=100, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='optimized code NLMS for DoA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.M = num_signals
              self.K = num_angles
              self.N = num_snapshots
              self.u = step_size
              
              # Precompute search angles and steering matrices
              self.angles = np.linspace(-90, 90, self.K)
              self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)
              for k in range(self.K):
                  theta = np.deg2rad(self.angles[k])
                  self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              n_output = len(out)
              
              # Precompute Hermitian (conjugate transpose) of the steering matrix
              # steering_matrix is (2, K), so A_H becomes (K, 2)
              A_H = np.conj(self.steering_matrix).T
              
              for i in range(n_output):
                  # Extract N snapshots for this block processing step 
                  x0 = in0[i*self.N : (i+1)*self.N]
                  x1 = in1[i*self.N : (i+1)*self.N]
                  
                  # Stack into an (N, 2) matrix
                  X = np.column_stack([x0, x1]).astype(np.complex128)
                  
                  # Initialize weight vectors for ALL K angles simultaneously: shape (K, 2)
                  W = np.zeros((self.K, 2), dtype=np.complex128)
                  
                  # Precompute desired signal 'd' for all angles across all snapshots
                  # Matrix multiply: (K, 2) x (2, N) -> Resulting shape is (K, N)
                  D_matrix = A_H @ X.T
                  
                  # Loop ONLY over the snapshots (100 steps instead of 18,100!)
                  for n in range(self.N):
                      x_n = X[n]  # Current 2-element snapshot vector: shape (2,)
                      
                      # Compute filter output y = w^H * x_n for all K angles simultaneously
                      # Row-wise dot product via broadcasting and summing along columns
                      Y = np.sum(np.conj(W) * x_n, axis=1)  # shape (K,)
                      
                      # Extract desired signal vector for this snapshot step
                      D = D_matrix[:, n]  # shape (K,)
                      
                      # Scalar error for all angles
                      E = D - Y  # shape (K,)
                      
                      # Squared norm of the input vector (scalar, identical across all angles)
                      xns = np.sum(np.abs(x_n)**2) + 1e-10
                      
                      # Fully vectorized NLMS weight update rule across all angles
                      # (K, 1) matrix multiplied by (1, 2) matrix updates the (K, 2) weight matrix instantly
                      W += (self.u / xns) * (np.conj(E)[:, None] * x_n[None, :])
                  
                  # Compute Euclidean norm of final weights for each angle out of the loop
                  norms = np.linalg.norm(W, axis=1)
                  
                  # Normalize the spectrum so the peak equals 1.0 (0 dB)
                  '''max_norm = np.max(norms)
                  if max_norm > 0:
                      norms /= max_norm'''
                      
                  out[i][:] = norms
                  
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  print(f"NLMS Peak detected at: {self.angles[max_idx]:.1f}°")
                  
              return n_output
    num_angles: '181'
    num_signals: '1'
    num_snapshots: '100'
    step_size: '0.01'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class bartlett_doa(gr.decim_block):
          def __init__(self, num_angles=181, num_snapshots=30):
              # We inherit from decim_block and set the decimation factor to num_snapshots
              gr.decim_block.__init__(
                  self,
                  name='Bartlett DoA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.K = num_angles
              self.N = num_snapshots
              
              # Precompute angles and steering matrix to make the block fast
              self.angles = np.linspace(-90, 90, self.K)
              self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)
              for k in range(self.K):
                  theta = np.deg2rad(self.angles[k])
                  # For half-wavelength antenna spacing (d = lambda / 2)
                  self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              # Determine how many output vectors the scheduler wants us to fill
              n_output = len(out)
              
              for i in range(n_output):
                  # Extract the correct window of N snapshots for this output step
                  x0 = in0[i*self.N : (i+1)*self.N]
                  x1 = in1[i*self.N : (i+1)*self.N]
                  
                  X = np.vstack([x0, x1]).astype(np.complex128)
                  
                  # Calculate the Sample Covariance Matrix R
                  R = (X @ X.conj().T) / self.N
                  
                  # Compute Bartlett power spectrum
                  powers = np.zeros(self.K, dtype=np.float32)
                  for k in range(self.K):
                      a = self.steering_matrix[:, k]
                      p = np.real(a.conj().T @ R @ a)
                      powers[k] = p
                  
                  # Normalize to 1.0 so the peak matches 0 dB on your plot
                  max_p = np.max(powers)
                  if max_p > 0:
                      powers /= max_p
                  
                  out[i][:] = powers
                  
              # Print the peak from the most recent window to the console
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  print(f"Peak detected at: {self.angles[max_idx]:.1f}°")
                  
              return n_output
    num_angles: '181'
    num_snapshots: '100'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          def __init__(self, num_signals=1, num_angles=91, num_snapshots=50, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='ultra lightweight Block-NLMS for DoA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.M = num_signals
              self.K = num_angles
              self.N = num_snapshots
              self.u = step_size

              # Precompute search angles and steering matrices
              self.angles = np.linspace(-90, 90, self.K)
              self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)
              for k in range(self.K):
                  theta = np.deg2rad(self.angles[k])
                  self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              n_output = len(out)
              A_H = np.conj(self.steering_matrix).T  # Shape: (K, 2)
              
              for i in range(n_output):
                  # Extract the N snapshots for this block
                  x0 = in0[i*self.N : (i+1)*self.N]
                  x1 = in1[i*self.N : (i+1)*self.N]
                  X = np.column_stack([x0, x1]).astype(np.complex128)  # Shape: (N, 2)
                  
                  # 1. Compute average snapshot power across the entire block instantly
                  block_power = np.sum(np.abs(X)**2) / self.N + 1e-10
                  
                  # 2. Compute the spatial baseline matrix: (K, 2) @ (2, N) -> (K, N)
                  D_matrix = A_H @ X.T
                  
                  for n in range(self.N):
                      x_n = X[n]               # Shape: (2,)
                      x_n_conj = np.conj(x_n)  # Shape: (2,)
                      
                      # 1. ACTUAL ESTIMATE: y = w^H * x  -> maps to C BLAS: W_c @ x_n
                      Y = W_c @ x_n 
                      
                      # 2. THE ERROR: e = d - y
                      E = D_matrix[:, n] - Y
                      
                      # 3. Input Power: ||x||^2
                      xns = np.real(x_n_conj @ x_n) + 1e-10
                      
                      # 4. WEIGHT UPDATE: w = w + mu * e * x / power
                      # Using np.outer(E, x_n_conj) applies this to all 181 angles instantly
                      W_c += (self.u / xns) * np.outer(E, x_n_conj)
                  
                  # Norm of W_c is identical to norm of W
                  norms = np.linalg.norm(W_c, axis=1)
                      
                  out[i][:] = norms
                  
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  print(f"NLMS Peak detected at: {self.angles[max_idx]:.1f}°")
                  
              return n_output
                  
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  print(f"Block-NLMS Peak detected at: {self.angles[max_idx]:.1f}°")
                  
              return n_output
    num_angles: '91'
    num_signals: '1'
    num_snapshots: '50'
    step_size: '0.5'
  states: {state: disabled}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          def __init__(self, num_signals=1, num_angles=181, num_snapshots=50, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='ultra lightweight Block-NLMS for DoA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.M = num_signals
              self.K = num_angles
              self.N = num_snapshots
              self.u = step_size

              # Precompute search angles and steering matrices
              self.angles = np.linspace(-90, 90, self.K)
              self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)
              for k in range(self.K):
                  theta = np.deg2rad(self.angles[k])
                  self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              n_output = len(out)
              A_H = np.conj(self.steering_matrix).T  # Shape: (K, 2)
              
              for i in range(n_output):
                  # Extract the N snapshots for this block
                  x0 = in0[i*self.N : (i+1)*self.N]
                  x1 = in1[i*self.N : (i+1)*self.N]
                  X = np.column_stack([x0, x1]).astype(np.complex128)  # Shape: (N, 2)
                  
                  # 1. Compute average snapshot power across the entire block instantly
                  block_power = np.sum(np.abs(X)**2) / self.N + 1e-10
                  
                  # 2. Compute the spatial baseline matrix: (K, 2) @ (2, N) -> (K, N)
                  D_matrix = A_H @ X.T
                  
                  # 3. CLOSED-FORM BLOCK UPDATE (Zero Loops!)
                  # Instead of stepping snapshot-by-snapshot, we multiply the entire 
                  # data matrices together. This maps directly to ultra-fast hardware BLAS.
                  # Matrix multiply: (K, N) @ (N, 2) -> Resulting shape is (K, 2)
                  W_c = (self.u / block_power) * (D_matrix @ np.conj(X))
                  
                  # 4. Calculate the spatial spectrum norms directly from W_c
                  norms = np.linalg.norm(W_c, axis=1)
                      
                  out[i][:] = norms
                  
              if n_output > 0:
                  max_idx = np.argmax(out[-1])
                  print(f"Block-NLMS Peak detected at: {self.angles[max_idx]:.1f}°")
                  
              return n_output
    num_angles: '181'
    num_signals: '1'
    num_snapshots: '30'
    step_size: '0.1'
  states: {state: disabled}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\n\nclass nlms_doa(gr.decim_block):\n    def __init__(self, num_signals=1, num_angles=91, num_snapshots=100, step_size=0.2):\n        gr.decim_block.__init__(\n            self,\n            name='Exact Recursive NLMS for DoA',\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[(np.float32, num_angles)],\n            decim=num_snapshots\n        )\n        self.M = num_signals\n        self.K = num_angles\n        self.N = num_snapshots\n        self.u = step_size\n\n        # Precompute search angles and steering matrices\n        self.angles = np.linspace(-90, 90, self.K)\n        self.steering_matrix = np.zeros((2, self.K), dtype=np.complex128)\n        for k in range(self.K):\n            theta = np.deg2rad(self.angles[k])\n            self.steering_matrix[:, k] = [1.0, np.exp(-1j * np.pi * np.sin(theta))]\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        in1 = input_items[1]\n        out = output_items[0]\n        \n        n_output = len(out)\n        \n        # Precompute Hermitian of the steering matrix: shape (K, 2)\n        A_H = np.conj(self.steering_matrix).T\n        \n        for i in range(n_output):\n            x0 = in0[i*self.N : (i+1)*self.N]\n            x1 = in1[i*self.N : (i+1)*self.N]\n            \n            # Stack into an (N, 2) matrix\n            X = np.column_stack([x0, x1]).astype(np.complex128)\n            \n            # Initialize weights to 0 for this block\n            W_c = np.zeros((self.K, 2), dtype=np.complex128)\n            \n            # Precompute desired signal 'd' across space: (K, 2) @ (2, N) -> (K, N)\n            D_matrix = A_H @ X.T\n            \n            # --- THE RECURSIVE ADAPTIVE LOOP ---\n            # We MUST step through time to calculate the true error\n            for n in range(self.N):\n                x_n = X[n]               # Shape: (2,)\n                x_n_conj = np.conj(x_n)  # Shape: (2,)\n                \n                # 1. ACTUAL ESTIMATE: y = w^H * x  -> maps to C BLAS: W_c @ x_n\n                Y = W_c @ x_n \n                \n                # 2. THE ERROR: e = d - y\n                E = D_matrix[:, n] - Y\n                \n                # 3. Input Power: ||x||^2\n                xns = np.real(x_n_conj @ x_n) + 1e-10\n                \n                # 4. WEIGHT UPDATE: w = w + mu * e * x / power\n                # Using np.outer(E, x_n_conj) applies this to all 181 angles instantly\n                W_c += (self.u / xns) * np.outer(E, x_n_conj)\n            \n            # Norm of W_c is identical to norm of W\n            norms = np.linalg.norm(W_c, axis=1)\n                \n            out[i][:] = norms\n            \n        if n_output > 0:\n            max_idx = np.argmax(out[-1])\n            print(f\"NLMS Peak detected at: {self.angles[max_idx]:.1f}°\")\n            \n        return n_output\n\n\n"
    num_angles: '91'
    num_signals: '1'
    num_snapshots: '50'
    step_size: '0.1'
  states: {state: disabled}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          def __init__(self, num_angles=181, num_snapshots=50, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='claude NLMS DOA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.K   = num_angles
              self.N   = num_snapshots
              self.mu  = np.float32(step_size)
              self._n  = 0  # call counter for throttled print

              # One block per work() call — keeps GIL held for <1 ms
              self.set_max_noutput_items(1)

              # ── Steering matrix: precomputed once, never touched again ───────────
              theta = np.deg2rad(np.linspace(-90.0, 90.0, self.K))
              A = np.ones((2, self.K), dtype=np.complex64)
              A[1] = np.exp(-1j * np.pi * np.sin(theta)).astype(np.complex64)
              # A_H: (K, 2) conjugate-transpose, C-contiguous for fast BLAS
              self.A_H    = np.ascontiguousarray(np.conj(A).T)
              self.angles = np.linspace(-90.0, 90.0, self.K)

              # ── Preallocate every buffer — work() will NEVER call malloc ─────────
              self.X     = np.zeros((self.N, 2),      dtype=np.complex64)
              self.W     = np.zeros((self.K, 2),      dtype=np.complex64)
              self.D     = np.zeros((self.K, self.N), dtype=np.complex64)
              self.Y     = np.zeros(self.K,           dtype=np.complex64)
              self.E     = np.zeros(self.K,           dtype=np.complex64)
              self.dW    = np.zeros((self.K, 2),      dtype=np.complex64)
              self.x_c   = np.zeros(2,               dtype=np.complex64)
              self.nsq   = np.zeros(self.K,           dtype=np.float32)
              self.norms = np.zeros(self.K,           dtype=np.float32)

              kb = sum(a.nbytes for a in [self.A_H, self.X, self.W, self.D,
                        self.Y, self.E, self.dW, self.x_c, self.nsq, self.norms]) / 1024
              print(f"[NLMS DOA] K={self.K}  N={self.N}  mu={step_size}  | {kb:.0f} KB fixed")

          def work(self, input_items, output_items):
              # ── Load snapshots into preallocated X: (N, 2) ──────────────────────
              self.X[:, 0] = input_items[0][:self.N]
              self.X[:, 1] = input_items[1][:self.N]

              # ── D = A_H @ X.T → (K, N): all desired signals, one BLAS call ─────
              np.dot(self.A_H, self.X.T, out=self.D)

              # ── Reset weights ────────────────────────────────────────────────────
              self.W[:] = 0.0

              # ── NLMS: K angles in parallel, loop only over N snapshots ──────────
              for n in range(self.N):
                  x_n = self.X[n]  # (2,) view — no copy

                  # ||x_n||² as float32 scalar
                  xns = np.float32(x_n.real @ x_n.real
                                 + x_n.imag @ x_n.imag) + np.float32(1e-6)

                  np.conj(x_n, out=self.x_c)               # x_c = conj(x_n)
                  np.dot(self.W, x_n, out=self.Y)           # Y = W·x  (= w^H·x)
                  np.subtract(self.D[:, n], self.Y, out=self.E)  # E = d - y

                  # dW = outer(E, x_c), then W += (mu/||x||²)·dW  — all in-place
                  np.multiply(self.E[:, None], self.x_c[None, :], out=self.dW)
                  self.dW *= (self.mu / xns)
                  self.W  += self.dW

              # ── ||w_k|| with zero allocation: view complex64 as float32 ─────────
              W_f = self.W.view(np.float32).reshape(self.K, 4)
              np.einsum('ki,ki->k', W_f, W_f, out=self.nsq)  # squared norms
              np.sqrt(self.nsq, out=self.norms)               # final norms

              output_items[0][0][:] = self.norms

              # Print ~4×/sec — not every call (would slow work() significantly)
              self._n += 1
              if self._n % 1000 == 0:
                  print(f"[NLMS] Peak → {self.angles[np.argmax(self.norms)]:.1f}°")

              return 1
    num_angles: '181'
    num_snapshots: '50'
    step_size: '0.2'
  states: {state: disabled}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      # ── Numba kernel: compiled once, then runs at near-C speed on all cores ────────
      try:
          from numba import njit, prange

          @njit(parallel=True, cache=True, fastmath=True)
          def _nlms_kernel(A_H, X, mu):
              """
              Each angle k runs on a separate CPU core (prange).
              No heap, no GIL, no Python — pure native code after first JIT call.
              A_H : (K, 2) complex64  — conjugated steering matrix
              X   : (N, 2) complex64  — snapshot block
              mu  : float32           — step size
              """
              K      = A_H.shape[0]
              N      = X.shape[0]
              norms  = np.zeros(K, dtype=np.float32)

              for k in prange(K):                    # ← all K angles in parallel
                  w0 = np.complex64(0.0)
                  w1 = np.complex64(0.0)
                  a0 = A_H[k, 0]                     # desired filter target, element 0
                  a1 = A_H[k, 1]                     # desired filter target, element 1

                  for n in range(N):                 # ← sequential (NLMS recurrence)
                      x0   = X[n, 0]
                      x1   = X[n, 1]
                      xns  = (x0.real*x0.real + x0.imag*x0.imag +
                              x1.real*x1.real + x1.imag*x1.imag +
                              np.float32(1e-6))       # ||x_n||²
                      d    = a0*x0 + a1*x1           # desired  :  a^H · x_n
                      y    = w0*x0 + w1*x1           # output   :  ŵ^H · x_n
                      e    = d - y                   # error
                      s    = mu / xns               # NLMS step size
                      w0  += s * e * np.conj(x0)    # weight update (conj stored)
                      w1  += s * e * np.conj(x1)

                  norms[k] = np.sqrt(w0.real*w0.real + w0.imag*w0.imag +
                                     w1.real*w1.real + w1.imag*w1.imag)
              return norms

          _NUMBA = True
          print("[NLMS DOA] Numba found — parallel JIT mode active")

      except ImportError:
          _NUMBA = False
          print("[NLMS DOA] Numba not found — falling back to numpy")


      class nlms_doa(gr.decim_block):
          """
          NLMS DOA for USRP X310, 2-element ULA.
          With Numba:    runs K=181, N=100 comfortably at 500 kHz
          Without Numba: use K=61, N=30, samp_rate ≤ 100 kHz
          """
          def __init__(self, num_angles=91, num_snapshots=10, step_size=0.2):
              gr.decim_block.__init__(
                  self,
                  name='NLMS DOA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.K   = num_angles
              self.N   = num_snapshots
              self.mu  = np.float32(step_size)
              self._t  = 0                           # throttle print counter

              # One block per work() → GIL held for one block at a time only
              self.set_max_noutput_items(1)

              # Steering matrix: (2, K) complex64, precomputed once
              theta    = np.deg2rad(np.linspace(-90.0, 90.0, self.K))
              A        = np.ones((2, self.K), dtype=np.complex64)
              A[1]     = np.exp(-1j * np.pi * np.sin(theta)).astype(np.complex64)
              self.A_H = np.ascontiguousarray(np.conj(A).T)   # (K, 2), C-contiguous
              self.ang = np.linspace(-90.0, 90.0, self.K)

              # Numpy-fallback buffers (only used when Numba is absent)
              self.X     = np.zeros((self.N, 2),      dtype=np.complex64)
              self.W     = np.zeros((self.K, 2),      dtype=np.complex64)
              self.D     = np.zeros((self.K, self.N), dtype=np.complex64)
              self.Y     = np.zeros(self.K,           dtype=np.complex64)
              self.E     = np.zeros(self.K,           dtype=np.complex64)
              self.dW    = np.zeros((self.K, 2),      dtype=np.complex64)
              self.x_c   = np.zeros(2,               dtype=np.complex64)
              self.nsq   = np.zeros(self.K,           dtype=np.float32)
              self.norms = np.zeros(self.K,           dtype=np.float32)

              mode = "Numba parallel" if _NUMBA else "numpy (install numba for 50× speedup)"
              print(f"[NLMS DOA] K={self.K}  N={self.N}  mu={step_size}  | {mode}")

          # ── Numpy fallback (preallocated, zero-alloc in loop) ──────────────────────
          def _nlms_numpy(self):
              np.dot(self.A_H, self.X.T, out=self.D)
              self.W[:] = 0.0
              for n in range(self.N):
                  x_n  = self.X[n]
                  xns  = np.float32(x_n.real @ x_n.real
                                  + x_n.imag @ x_n.imag + 1e-6)
                  np.conj(x_n, out=self.x_c)
                  np.dot(self.W, x_n, out=self.Y)
                  np.subtract(self.D[:, n], self.Y, out=self.E)
                  np.multiply(self.E[:, None], self.x_c[None, :], out=self.dW)
                  self.dW *= (self.mu / xns)
                  self.W  += self.dW
              W_f = self.W.view(np.float32).reshape(self.K, 4)
              np.einsum('ki,ki->k', W_f, W_f, out=self.nsq)
              np.sqrt(self.nsq, out=self.norms)
              return self.norms

          # ── work() ─────────────────────────────────────────────────────────────────
          def work(self, input_items, output_items):
              self.X[:, 0] = input_items[0][:self.N]
              self.X[:, 1] = input_items[1][:self.N]

              if _NUMBA:
                  norms = _nlms_kernel(self.A_H, self.X, self.mu)
              else:
                  norms = self._nlms_numpy()

              output_items[0][0][:] = norms

              self._t += 1
              if self._t % 500 == 0:
                  print(f"[NLMS] {self.ang[np.argmax(norms)]:.1f}°")

              return 1
    num_angles: '91'
    num_snapshots: '20'
    step_size: '0.2'
  states: {state: disabled}
- name: epy_block_6
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          """
          Block-NLMS DOA — proper error feedback, no inner N-loop.

          Previous code:  W = (μ/P·pwr)·D·X*          (y=0 assumed, error missing)
          This code:      for P passes: E = D − W·X^T   (true error each pass)
                                        W += (μ/P·pwr)·E·X*
          Same matrix structure, same speed, correct NLMS.
          """
          def __init__(self, num_angles=91, num_snapshots=30,
                       step_size=0.2, num_passes=3):
              gr.decim_block.__init__(
                  self,
                  name='Block-NLMS DOA',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.K   = num_angles
              self.N   = num_snapshots
              self.mu  = np.float32(step_size)
              self.P   = num_passes
              self._cnt = 0
              self.set_max_noutput_items(1)

              # Steering matrix A_H: (K, 2) complex64 — computed once, never again
              theta    = np.deg2rad(np.linspace(-90.0, 90.0, self.K))
              A        = np.ones((2, self.K), dtype=np.complex64)
              A[1]     = np.exp(-1j * np.pi * np.sin(theta)).astype(np.complex64)
              self.A_H = np.ascontiguousarray(np.conj(A).T)   # (K, 2)
              self.ang = np.linspace(-90.0, 90.0, self.K)

              # Pre-allocate every buffer — zero malloc in work()
              self.X    = np.zeros((self.N, 2),       dtype=np.complex64)  # snapshots
              self.X_c  = np.zeros((self.N, 2),       dtype=np.complex64)  # conj(X)
              self.D    = np.zeros((self.K, self.N),  dtype=np.complex64)  # desired
              self.W    = np.zeros((self.K, 2),       dtype=np.complex64)  # weights
              self.Y    = np.zeros((self.K, self.N),  dtype=np.complex64)  # filter out
              self.E    = np.zeros((self.K, self.N),  dtype=np.complex64)  # error
              self.dW   = np.zeros((self.K, 2),       dtype=np.complex64)  # weight Δ
              self.nsq  = np.zeros(self.K,            dtype=np.float32)
              self.norms= np.zeros(self.K,            dtype=np.float32)

              kb = sum(a.nbytes for a in [self.A_H, self.X, self.X_c, self.D,
                        self.W, self.Y, self.E, self.dW, self.nsq, self.norms]) / 1024
              print(f"[Block-NLMS] K={self.K} N={self.N} "
                    f"passes={self.P} mu={step_size} | {kb:.0f} KB fixed")

          def work(self, input_items, output_items):

              # ── 1. Load snapshots ─────────────────────────────────────────────────
              self.X[:, 0] = input_items[0][:self.N]
              self.X[:, 1] = input_items[1][:self.N]
              np.conj(self.X, out=self.X_c)

              # ── 2. Average block power (scalar, no allocation) ───────────────────
              X_f   = self.X.view(np.float32).reshape(self.N, 4)
              power = np.float32(np.einsum('ni,ni->', X_f, X_f) / self.N + 1e-6)

              # Step size split across P passes so total step ≈ μ/power
              scale = self.mu / (np.float32(self.P) * power)

              # ── 3. D = A_H @ X.T : (K,2)@(2,N) → (K,N) — one BLAS call ────────
              np.dot(self.A_H, self.X.T, out=self.D)

              # ── 4. Block-NLMS: P passes, proper error each time ──────────────────
              #
              #   pass 1:  W=0  →  Y=0  →  E=D          (same as old code)
              #   pass 2:  Y=W₁·Xᵀ  →  E=D−Y₁  ← ERROR TERM NOW CORRECT
              #   pass 3:  Y=W₂·Xᵀ  →  E=D−Y₂  ← refines further
              #
              self.W[:] = 0.0

              for _ in range(self.P):
                  np.dot(self.W, self.X.T, out=self.Y)        # Y  = W·X^T   (K,N)
                  np.subtract(self.D, self.Y, out=self.E)     # E  = D − Y   (K,N) ← error
                  np.dot(self.E, self.X_c,    out=self.dW)    # dW = E·X*    (K,2)
                  self.dW *= scale                             # scale in-place
                  self.W  += self.dW                           # W += dW      in-place

              # ── 5. Norms via float32 view — zero allocation ───────────────────────
              W_f = self.W.view(np.float32).reshape(self.K, 4)
              np.einsum('ki,ki->k', W_f, W_f, out=self.nsq)
              np.sqrt(self.nsq, out=self.norms)

              output_items[0][0][:] = self.norms

              self._cnt += 1
              if self._cnt % 500 == 0:
                  print(f"[NLMS] {self.ang[np.argmax(self.norms)]:.1f}°")

              return 1
    num_angles: '91'
    num_passes: '5'
    num_snapshots: '30'
    step_size: '0.2'
  states: {state: disabled}
- name: epy_block_7
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          """
          Ultra-Optimized Batch Block-NLMS DoA for USRP X310.
          Processes all available blocks in a single call to eliminate 
          Python context-switching overhead and prevent Overflows (OO).
          """
          def __init__(self, num_angles=91, num_snapshots=30,
                       step_size=0.2, num_passes=3):
              gr.decim_block.__init__(
                  self,
                  name='Block-NLMS DOA Optimized',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[(np.float32, num_angles)],
                  decim=num_snapshots
              )
              self.K   = num_angles
              self.N   = num_snapshots
              self.mu  = np.float32(step_size)
              self.P   = num_passes
              self._cnt = 0

              # Steering matrix A_H: (K, 2) complex64 — computed once at startup
              theta    = np.deg2rad(np.linspace(-90.0, 90.0, self.K))
              A        = np.ones((2, self.K), dtype=np.complex64)
              A[1]     = np.exp(-1j * np.pi * np.sin(theta)).astype(np.complex64)
              self.A_H = np.ascontiguousarray(np.conj(A).T)   # (K, 2)
              self.ang = np.linspace(-90.0, 90.0, self.K)

              # Pre-allocated single-block buffers to eliminate garbage collection
              self.X    = np.zeros((self.N, 2),       dtype=np.complex64)
              self.X_c  = np.zeros((self.N, 2),       dtype=np.complex64)
              self.D    = np.zeros((self.K, self.N),  dtype=np.complex64)
              self.W    = np.zeros((self.K, 2),       dtype=np.complex64)
              self.Y    = np.zeros((self.K, self.N),  dtype=np.complex64)
              self.E    = np.zeros((self.K, self.N),  dtype=np.complex64)
              self.dW   = np.zeros((self.K, 2),       dtype=np.complex64)
              self.nsq  = np.zeros(self.K,            dtype=np.float32)

              kb = sum(a.nbytes for a in [self.A_H, self.X, self.X_c, self.D,
                        self.W, self.Y, self.E, self.dW, self.nsq]) / 1024
              print(f"[Block-NLMS] K={self.K} N={self.N} passes={self.P} | {kb:.1f} KB Buffers Pre-allocated")

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out = output_items[0]
              
              # Determine how many output blocks GNU Radio wants us to produce
              n_output = len(out)
              
              # Process each block sequentially inside this fast loop
              for i in range(n_output):
                  start = i * self.N
                  end = start + self.N
                  
                  # 1. Slice items directly without reallocation
                  self.X[:, 0] = in0[start:end]
                  self.X[:, 1] = in1[start:end]
                  np.conj(self.X, out=self.X_c)

                  # 2. Fast C-level array power calculation (Re^2 + Im^2)
                  power = np.sum(self.X.real**2 + self.X.imag**2) / self.N + 1e-6
                  scale = self.mu / (np.float32(self.P) * power)

                  # 3. Reference Spatial Baseline: (K,2) @ (2,N) -> (K,N)
                  np.dot(self.A_H, self.X.T, out=self.D)

                  # 4. Multi-pass Block-NLMS core feedback loop
                  self.W[:] = 0.0
                  for _ in range(self.P):
                      np.dot(self.W, self.X.T, out=self.Y)            # Y = W @ X^T
                      np.subtract(self.D, self.Y, out=self.E)         # E = D - Y (Error feedback)
                      np.dot(self.E, self.X_c, out=self.dW)          # dW = E @ X*
                      self.dW *= scale
                      self.W  += self.dW

                  # 5. Fast Euclidean norm calculation written directly to GNU Radio's output buffer
                  np.sum(self.W.real**2 + self.W.imag**2, axis=1, out=self.nsq)
                  np.sqrt(self.nsq, out=out[i])

              # Periodically log findings to terminal to minimize print statements
              self._cnt += n_output
              if self._cnt >= 500:
                  self._cnt = 0
                  max_idx = np.argmax(out[-1])
                  print(f"[NLMS] Peak detected at: {self.ang[max_idx]:.1f}°")

              return n_output
    num_angles: '91'
    num_passes: '3'
    num_snapshots: '30'
    step_size: '0.2'
  states: {state: disabled}
- name: epy_block_8
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class nlms_doa(gr.decim_block):
          """
          Dual-Output Block-NLMS DOA with Physical Antenna Spacing Calibration.
          Port 0: 91-element Spatial Spectrum Vector
          Port 1: Clean Scalar Peak Angle (Degrees) for Compass/Number Sinks
          """
          def __init__(self, num_angles=91, num_snapshots=30,
                       step_size=0.2, num_passes=3, d_over_lambda=0.41): # Adjusted calibration factor
              gr.decim_block.__init__(
                  self,
                  name='Calibrated NLMS DOA',
                  in_sig=[np.complex64, np.complex64],
                  # Port 0 is a vector of size 91, Port 1 is a single scalar float
                  out_sig=[(np.float32, num_angles), np.float32], 
                  decim=num_snapshots
              )
              self.K   = num_angles
              self.N   = num_snapshots
              self.mu  = np.float32(step_size)
              self.P   = num_passes
              self.d_l = np.float32(d_over_lambda)
              self._cnt = 0

              # Steering matrix A_H with customizable antenna spacing
              self.ang = np.linspace(-90.0, 90.0, self.K)
              theta    = np.deg2rad(self.ang)
              A        = np.ones((2, self.K), dtype=np.complex64)
              # Standard: -1j * pi * sin(theta) -> Calibrated: -1j * 2 * pi * d_over_lambda * sin(theta)
              A[1]     = np.exp(-2j * np.pi * self.d_l * np.sin(theta)).astype(np.complex64)
              self.A_H = np.ascontiguousarray(np.conj(A).T)

              # Pre-allocated single-block buffers
              self.X    = np.zeros((self.N, 2),       dtype=np.complex64)
              self.X_c  = np.zeros((self.N, 2),       dtype=np.complex64)
              self.D    = np.zeros((self.K, self.N),  dtype=np.complex64)
              self.W    = np.zeros((self.K, 2),       dtype=np.complex64)
              self.Y    = np.zeros((self.K, self.N),  dtype=np.complex64)
              self.E    = np.zeros((self.K, self.N),  dtype=np.complex64)
              self.dW   = np.zeros((self.K, 2),       dtype=np.complex64)
              self.nsq  = np.zeros(self.K,            dtype=np.float32)

          def work(self, input_items, output_items):
              in0 = input_items[0]
              in1 = input_items[1]
              out_vector = output_items[0]
              out_scalar = output_items[1]
              
              n_output = len(out_vector)
              
              for i in range(n_output):
                  start = i * self.N
                  end = start + self.N
                  
                  self.X[:, 0] = in0[start:end]
                  self.X[:, 1] = in1[start:end]
                  np.conj(self.X, out=self.X_c)

                  power = np.sum(self.X.real**2 + self.X.imag**2) / self.N + 1e-6
                  scale = self.mu / (np.float32(self.P) * power)

                  np.dot(self.A_H, self.X.T, out=self.D)

                  self.W[:] = 0.0
                  for _ in range(self.P):
                      np.dot(self.W, self.X.T, out=self.Y)
                      np.subtract(self.D, self.Y, out=self.E)
                      np.dot(self.E, self.X_c, out=self.dW)
                      self.dW *= scale
                      self.W  += self.dW

                  # Calculate norms and write directly to the spectrum vector output
                  np.sum(self.W.real**2 + self.W.imag**2, axis=1, out=self.nsq)
                  np.sqrt(self.nsq, out=out_vector[i])

                  # Extract peak angle and assign it to the scalar output port
                  max_idx = np.argmax(out_vector[i])
                  peak_deg = self.ang[max_idx]
                  out_scalar[i] = peak_deg  # Sends precise float degree (e.g., 30.0)

              self._cnt += n_output
              if self._cnt >= 500:
                  self._cnt = 0
                  print(f"[NLMS Terminal] Calibrated Peak: {out_scalar[-1]:.1f}°")

              return n_output
    d_over_lambda: '0.5'
    num_angles: '91'
    num_passes: '3'
    num_snapshots: '30'
    step_size: '0.2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '0'
    min_size: '250'
    name: NLMS AoA
    setDebug: 'True'
    update_time: '0.2'
  states: {}
- name: qtgui_compass_0_0
  id: qtgui_compass
  parameters:
    fullNeedle: '0'
    min_size: '250'
    name: NLMS AoA
    setDebug: 'True'
    update_time: '0.2'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    type: short
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    avg: '0.5'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    name: '"NLMS AoA"'
    type: short
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '90'
    min: '-90'
    name: '"Barlett AoA"'
    type: short
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    type: short
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_0_2
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '-180'
    type: short
    update_time: '0.01'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    name: '"NLMS AoA"'
    update_time: '0.01'
    vlen: '91'
    x_start: '-90'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.05'
    grid: 'True'
    name: '"Barlett AoA"'
    update_time: '0.01'
    vlen: '181'
    x_start: '-90'
    x_step: '1.0'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.1'
    update_time: '0.5'
    vlen: '91'
    x_start: '-90'
    x_step: '1'
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: 10e3
    center_freq0: 2.5e9
    clock_source0: internal
    dev_addr: addr=192.168.10.2
    gain0: '13'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    bw0: 10e3
    bw1: 10e3
    center_freq0: 2.5e9
    center_freq1: 2.5e9
    clock_source0: internal
    dev_addr: addr=192.168.10.2
    gain0: '14'
    gain1: '14'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock_next_pps
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0_0_1, '0', uhd_usrp_sink_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_add_const_vxx_1, '0', blocks_short_to_float_0, '0']
- [blocks_argmax_xx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_argmax_xx_0, '1', qtgui_number_sink_0, '0']
- [blocks_argmax_xx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_argmax_xx_0_0, '1', qtgui_number_sink_0_1, '0']
- [blocks_argmax_xx_0_1, '0', blocks_add_const_vxx_1, '0']
- [blocks_argmax_xx_0_1, '1', qtgui_number_sink_0_2, '0']
- [blocks_phase_shift_0_0_0, '0', epy_block_0_0_0, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_1, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_2, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_2_0, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_3, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_4, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_5, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_6, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_7, '1']
- [blocks_phase_shift_0_0_0, '0', epy_block_8, '1']
- [blocks_short_to_float_0, '0', qtgui_compass_0, '0']
- [epy_block_0, '0', blocks_argmax_xx_0, '0']
- [epy_block_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0_0, '0', blocks_argmax_xx_0, '0']
- [epy_block_0_0, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_0_0_0, '0', blocks_argmax_xx_0, '0']
- [epy_block_0_0_0, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_1, '0', blocks_argmax_xx_0_0, '0']
- [epy_block_1, '0', qtgui_vector_sink_f_0_0, '0']
- [epy_block_2, '0', blocks_argmax_xx_0, '0']
- [epy_block_2, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_2, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_2_0, '0', blocks_argmax_xx_0, '0']
- [epy_block_2_0, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_3, '0', blocks_argmax_xx_0, '0']
- [epy_block_3, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_3, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_4, '0', blocks_argmax_xx_0, '0']
- [epy_block_4, '0', qtgui_vector_sink_f_0, '0']
- [epy_block_5, '0', blocks_argmax_xx_0, '0']
- [epy_block_5, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_6, '0', blocks_argmax_xx_0, '0']
- [epy_block_6, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_7, '0', blocks_argmax_xx_0_1, '0']
- [epy_block_7, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_8, '0', blocks_argmax_xx_0_1, '0']
- [epy_block_8, '0', qtgui_vector_sink_f_0_1, '0']
- [epy_block_8, '1', qtgui_compass_0_0, '0']
- [uhd_usrp_source_0_0, '0', epy_block_0_0_0, '0']
- [uhd_usrp_source_0_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0_0, '0', epy_block_2, '0']
- [uhd_usrp_source_0_0, '0', epy_block_2_0, '0']
- [uhd_usrp_source_0_0, '0', epy_block_3, '0']
- [uhd_usrp_source_0_0, '0', epy_block_4, '0']
- [uhd_usrp_source_0_0, '0', epy_block_5, '0']
- [uhd_usrp_source_0_0, '0', epy_block_6, '0']
- [uhd_usrp_source_0_0, '0', epy_block_7, '0']
- [uhd_usrp_source_0_0, '0', epy_block_8, '0']
- [uhd_usrp_source_0_0, '1', blocks_phase_shift_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
